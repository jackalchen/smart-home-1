# IAR project Backup of Basic Comms - Router - SAPI.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: SIMPLE_API_VERBOSE
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..; ../ZNP; ../HAL; ../Common
  ICC430.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  ICC430.CCOptLevel: 2
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
  group (top)
    ../: example_basic_comms_router_sapi.c znp_example_utils.c
  group Common
    ../../Common/: printf.c utilities.c
  group HAL
    ../../HAL/: hal_cc2530znp_target_board.c
  group ZNP
    ../../ZNP/: application_configuration.c simple_api.c znp_interface.c znp_interface_spi.c
